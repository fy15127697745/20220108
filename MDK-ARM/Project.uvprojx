# Keil uVision project Project.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_IAP_TEST +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\MDK-ARM;..\Librarise\CM3;..\Librarise\STM32F10x_FWLib\inc;..\User\SYSTEM\sys;..\User\UserApp\user_main;..\User\UserApp\delay;..\User\UserApp\user_flash;..\User\UserApp\user_iap;..\User\UserApp\SYS;..\User\UserApp\usart_dev;..\User\UserApp\timer_dev;..\User\UserApp\led_dev
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Statrup
    ../Librarise/CM3/: startup_stm32f10x_hd.s
  group CMSIS
    ../Librarise/CM3/: core_cm3.c
  group Frame
    ./: stm32f10x_it.c system_stm32f10x.c
    ../User/SYSTEM/sys/: sys.c
    ../User/UserApp/SYS/: system.c
  group Appliction
    ../User/UserApp/user_main/: SysMain.c
    ../User/UserApp/delay/: delay.c
    ../User/UserApp/user_iap/: iap.c
    ../User/UserApp/user_flash/: flash.c
    ../User/UserApp/timer_dev/: timer.c
    ../User/UserApp/usart_dev/: usart.c
    ../User/UserApp/led_dev/: led.c
  group STM32F10x_FWLib
    ../Librarise/STM32F10x_FWLib/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
